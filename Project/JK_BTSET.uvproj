# Keil uVision project JK_BTSET.uvproj, settings and files
target JK_BTSET (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: JK_BTSET +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\update\UP407.BIN ..\Output\JK_BTSET.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_USB_OTG_FS,USE_EMBEDDED_PHY,USE_USB_OTG_HS
  c misc: --no-multibyte-chars --diag_suppress=870
  c include: ..\APP;..\drive;..\Include;..\Libraries\CMSIS\inc;..\Libraries\CMSIS\src;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\Listing;..\Output;..\Project;..\STemWinLibrary522\Config;..\STemWinLibrary522\emWinTask;..\STemWinLibrary522\GUILib;..\STemWinLibrary522\inc;..\User;..\USB\STM32_USB_HOST_Library\Class\HID\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\src;..\USB\STM32_USB_HOST_Library\Core\src;..\USB\USB_APP;..\USB\STM32_USB_HOST_Library\Class\HID\src;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_OTG_Driver\inc;..\FATFS\exfuns;..\FATFS\src\option;..\FATFS\src;..\MALLOC
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/inc/: core_cm4.h core_cm4_simd.h
    ../Libraries/CMSIS/src/: startup_stm32f40_41xxx.s
    ../User/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Libraries
    ../Libraries/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.h stm32f4xx_it.c
  group drive
    ../drive/: adc.c AT24C01.c BEEP.c bsp_SysTick.c flash.c GPIO.c IIC_24C01.c iwdg.c key.c modbus.c ssd1963.c TIM1.c TIM6.c usart.c TM1650.c clock.c AD7689.c TIM4.c AD5541.c CONT.c TIM3.c
  group STEMWIN
    ../STemWinLibrary522/Config/: GUI_X.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary522/emWinTask/: MainTask.c
    ../STemWinLibrary522/GUILib/: STemWin522_CM4_Keil.lib
  group APP
    ../APP/: menu.c R_Face.c load_Face.c graph_Face.c syssetting_Face.c cdcharge_Face.c sysflag.c sysinfo.c
  group FAST
    ../drive/: HZ16.c HZ12.c ENG16.c SONG12.c SONG16.c SONGB16.c SONG32.c SONGB12.c SONG26.c
  group USB_HOST
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c
